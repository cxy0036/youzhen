# IAR project PL3000_STM8S.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: C:\Users\yz\Desktop\烧录\PL3000\PL3000\Program\PL3000_STM8\StdPeriph\inc; C:\Users\yz\Desktop\烧录\PL3000\PL3000\Program\PL3000_STM8\USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PL3000_STM8S.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph
    StdPeriph/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group User
    USER/: ADC.c Bluetooth.c clock_config.c delay.c error_chk.c flash_times.c GPIO_Config.c HV_Charge.c KEY_FTC332.c LED.c main.c protocol.c stm8s_it.c UART.c
