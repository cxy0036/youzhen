# Keil uVision project probe_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F570210 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: probe_project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Option File
  asm include: .\Option File
  group Source Group 1
    ./: STARTUP.A51
    ./Option File/: OPTIONS_SN8F5702.A51
  group User
    ./User/: main.c delay.c EEPROM.c protocol.c UART.c Error_Check.c Flash_Control.c init.c key.c skin_color_check.c ADC.c
