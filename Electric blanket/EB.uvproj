# Keil uVision project EB.uvproj, settings and files
target DEMO (MCS-51)
  device: SN8F570202 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: EB
  c flags: Optimize=8 SizeSpeed=1
  group SRC
    ./SRC/: MAIN.C
  group ASM
    ./: STARTUP.A51
